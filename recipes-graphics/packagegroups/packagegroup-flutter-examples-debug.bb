include packagegroup-flutter-examples.inc

FLUTTER_RUNTIME = "debug"

DEPENDS += "\
    flutter-engine-${FLUTTER_RUNTIME} \
    "
