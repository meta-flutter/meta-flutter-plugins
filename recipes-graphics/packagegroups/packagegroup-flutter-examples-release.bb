include packagegroup-flutter-examples.inc

FLUTTER_RUNTIME = "release"

DEPENDS += "\
    flutter-engine-${FLUTTER_RUNTIME} \
    "
