include packagegroup-flutter-examples.inc

FLUTTER_RUNTIME = "profile"

DEPENDS += "\
    flutter-engine-${FLUTTER_RUNTIME} \
    "
